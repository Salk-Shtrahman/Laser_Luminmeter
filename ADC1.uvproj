# Keil uVision project ADC1.uvproj, settings and files
target ADC1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ADC1 +hex
  c flags: Optimize=9
  group Source
    ./: temporal pattern separation.c
